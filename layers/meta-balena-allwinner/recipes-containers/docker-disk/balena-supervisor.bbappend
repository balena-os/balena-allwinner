LED_FILE_orange-pi-lite = "/sys/devices/platform/leds/leds/orangepi\:red\:status/brightness"
LED_FILE_orange-pi-zero = "/sys/devices/platform/leds/leds/orangepi\:red\:status/brightness"
LED_FILE_bananapi-m1-plus = "/sys/class/leds/bananapi-m1-plus\:green\:usr/brightness"
LED_FILE_nanopi-neo-air = "/sys/class/leds/nanopi\:blue\:status/brightness"
