# Flash to internal eMMC - kernel always enumerates emmc as mmcblk2
INTERNAL_DEVICE_KERNEL_nanopi-neo-air = "mmcblk2"

INTERNAL_DEVICE_KERNEL_orangepi-plus2 = "mmcblk2"
INTERNAL_DEVICE_KERNEL_orange-pi-pc-plus = "mmcblk2"