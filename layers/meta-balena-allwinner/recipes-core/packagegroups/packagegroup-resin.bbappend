RDEPENDS_${PN}_append_nanopi-neo-air = " brcm-patchram-plus \
	nanopi-air-bt \
"
