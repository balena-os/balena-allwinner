FILESEXTRAPATHS_prepend := "${THISDIR}/linux-sunxi/:"

inherit kernel-resin
