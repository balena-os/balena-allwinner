include resin-image.inc