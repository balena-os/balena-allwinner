CONNECTIVITY_MODULES_append = " rtl8189"
